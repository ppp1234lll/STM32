# Keil uVision project Template.uvprojx, settings and files
target DATA_COLLECT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: data_collect +hex
  AfterMake: .\HEXBIN.bat $K !L @L $L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __CC_ARM
  c include: ..\CORE;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\MALLOC;..\LWIP;..\LWIP\arch;..\LWIP\lwip_header;..\LWIP\app\TCP_Client;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\tcp_client;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\INCLUDE;..\LITTLEFS;..\LWIP\lwip_app;..\APP\USER\inc;..\SYSTEM;..\APP\DRIVER\inc;..\HARDWARE\inc;..\APP\TOOL\inc;..\APP\TASK\inc;..\LWIP\lwip_app\onvif;..\LWIP\lwip_app\tcp_client;..\LWIP\lwip_app\tcp_server;..\LWIP\lwip_app\web_server;..\LWIP\lwip_app\ping;..\FWLIB\STM32_Cryptographic\include;..\APP\PRINT;..\SEGGER\RTT Viewer;..\SEGGER\HardFaultHandlerMDK;..\APP\UPDATE\inc;..\SEGGER\CmBacktrace;..\LWIP\lwip-1.4.1\src\include\ipv4\lwip;..\Middlewares\easybutton;..\Middlewares\lis3dh;..\LWIP\lwip_app\port_scan;..\LWIP\lwip_app\rtsp_client
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\local_ram_config.sct
  group APP/USER
    ../APP/USER/src/: start.c save.c com.c
  group APP/TASK
    ../APP/TASK/src/: app.c det.c eth.c gsm.c
  group APP/INCLUDE
    ../INCLUDE/: appconfig.h bsp.h
  group APP/TOOL
    ../APP/TOOL/src/: cJSON.c crc.c mycJSON.c Queue.c tool.c mydecrypt.c myencrypt.c md5.c de_encode.c SHA1.c
  group APP/DRIVER
    ../APP/DRIVER/src/: lan8720.c aht20.c aht20_drv.c w25qxx.c BL0910_SPI.c BL0942_SPI.c BH1750.c ATGM336H.c BL0939_SPI.c
  group APP/UPDATE
    ../APP/UPDATE/src/: update.c update_gsm.c update_lwip.c update_http.c
  group APP/DRIVER/GPRS
    ../APP/DRIVER/src/: GPRS.c GPS.c
  group APP/PRINT
    ../APP/PRINT/: print.c udp_multicast.c
  group MCU/USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group MCU/CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group MCU/SYSTEM
    ../SYSTEM/: delay.c sys.c
  group MCU/DRIVER
    ../HARDWARE/src/: stmflash.c bsp_core_dwt.c bsp_usart.c bsp_iwdg.c bsp_led.c bsp_key.c bsp_relay.c bsp_fan.c bsp_rtc.c bsp_rng.c bsp_dma.c bsp_timer.c bsp_spi_flash.c bsp_rs485.c bsp_uart_gprs.c bsp_hspi_energy.c bsp_hspi2_energy.c bsp_sspi_bl0939.c
  group MCU/FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_spi.c stm32f4xx_rng.c stm32f4xx_crc.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group MCU/MALLOC
    ../MALLOC/: malloc.c
  group Middlewares/LIS3DH
    ../Middlewares/lis3dh/: hal_lis3dh.c lis3dh_driver.c lis3dh_iic.c lis3dh_spi.c
  group MCU/Cryptographic
    ../FWLIB/STM32_Cryptographic/interface/: cmox_low_level_template.c
    ../FWLIB/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM4.a
  group LWIP/APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/ping/: lwip_ping.c
  group LWIP/APP/TCP
    ../LWIP/lwip_app/tcp_client/: tcp_client.c
  group LWIP/APP/WEB
    ../LWIP/lwip_app/web_server/: fs.c httpd.c httpd_cgi.c httpd_cgi_ssi.c httpd_ssi.c
  group LWIP/APP/PORT_SCAN
    ../LWIP/lwip_app/port_scan/: port_scan.c
  group LWIP/APP/RTSP
    ../LWIP/lwip_app/rtsp_client/: rtsp.c rtsp_task.c
  group LWIP/NETIF
    ../LWIP/lwip-1.4.1/src/netif/: ethernetif.c etharp.c
  group LWIP/CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP/ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP/API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group UCOSII/CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII/PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII/CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group LITTLEFS
    ../LITTLEFS/: lfs.c lfs_util.c lfs_port.c
  group HARDFAULT
    ../SEGGER/CmBacktrace/: cmb_cfg.h cm_backtrace.c
    ../SEGGER/CmBacktrace/fault_handler/keil/: cmb_fault.S
  group Readme
    ../: readme.txt
  group Middlewares/ebtn
    ../Middlewares/easybutton/: ebtn.c ebtn_APP.c ebtn_APP_Event.c ebtn_APP_HAL.c ebtn_APP_Keys.c
